# Repository dh219/pistorm

## KiCad design kicad/pistorm-ste/pistorm-ste.kicad_pcb

Board: 4 copper layers, 100.0 x 43.5 mm, 30 parts (0 on the bottom side), 125 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C13, C14: 100n; C_0805_2012Metric
C11, C12: 22u; C_0805_2012Metric
J1: Raspberry_Pi_2_3; PinSocket_2x20_P2.54mm_Vertical
J2: PLCC68_plug; PLCC68_male_pins
J3: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Horizontal
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
R1, R2: 4k7; R_0805_2012Metric
R3, R4: 0-100R; R_0805_2012Metric
U1, U7: SN54CBTD3384; TSSOP-24_4.4x7.8mm_P0.65mm
U2, U3, U5, U6: SN74LVC16373; TSSOP-48_6.1x12.5mm_P0.5mm
U4: EPM240T100; LQFP-100_14x14mm_P0.5mm
U8: LM1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C7.1, C8.1, C9.1, C10.1, C12.1, C13.1, C14.1, R1.1, R2.1, U2.7 (VCC), U2.18 (VCC), U2.31 (VCC), U2.42 (VCC), U3.7 (VCC), U3.18 (VCC), U3.31 (VCC), U3.42 (VCC), U4.9 (VCCIO1), U4.13 (VCCINT), U4.31 (VCCIO1), U4.45 (VCCIO1), U4.59 (VCCIO2), U4.63 (VCCINT), U4.80 (VCCIO2), U4.94 (VCCIO2), U5.7 (VCC), U5.18 (VCC), U5.31 (VCC), U5.42 (VCC), U6.7 (VCC), U6.18 (VCC), U6.31 (VCC), U6.42 (VCC), U8.2 (VO)
+5V: C5.1, C6.1, C11.1, J2.14, J2.52, J3.1, JP1.1 (A), U1.24 (VCC), U7.24 (VCC), U8.3 (VI)
/+5V_PI: J1.2 (5V), J1.4 (5V), JP1.2 (B)
/A1: J2.32, U2.3 (1Q2)
/A2: J2.33, U2.5 (1Q3)
/A3: J2.34, U2.6 (1Q4)
/A4: J2.35, U2.8 (1Q5)
/A5: J2.36, U2.9 (1Q6)
/A6: J2.37, U2.11 (1Q7)
/A7: J2.38, U2.12 (1Q8)
/A8: J2.39, U2.13 (2Q1)
/A9: J2.40, U2.14 (2Q2)
/A10: J2.41, U2.16 (2Q3)
/A11: J2.42, U2.17 (2Q4)
/A12: J2.43, U2.19 (2Q5)
/A13: J2.44, U2.20 (2Q6)
/A14: J2.45, U2.22 (2Q7)
/A15: J2.46, U2.23 (2Q8)
/A16: J2.47, U6.2 (1Q1)
/A17: J2.48, U6.3 (1Q2)
/A18: J2.49, U6.5 (1Q3)
/A19: J2.50, U6.6 (1Q4)
/A20: J2.51, U6.8 (1Q5)
/A21: J2.53, U6.9 (1Q6)
/A22: J2.54, U6.11 (1Q7)
/A23: J2.55, U6.12 (1Q8)
/ADDR_LTCH_0: U2.48 (1LE), U4.44 (IO1_44/DEV_CLRn)
/ADDR_LTCH_8: U2.25 (2LE), U4.42 (IO1_42)
/ADDR_LTCH_16: U4.47 (IO1_47), U6.48 (1LE)
/ADDR_LTCH_24: U4.48 (IO1_48), U6.25 (2LE)
/ADDR_OE: U2.1 (1OE), U2.24 (2OE), U4.43 (IO1_43/DEV_OE), U6.1 (1OE), U6.24 (2OE)
/AS: J2.6, U7.14 (2A1)
/AS_3: U4.72 (IO2_72), U7.15 (2B1)
/AUX0: J1.27 (ID_SD/GPIO0), U4.30 (IO1_30)
/AUX1: J1.28 (ID_SC/GPIO1), U4.33 (IO1_33)
/BERR: J2.24, U1.8 (1A4)
/BERR_3: U1.9 (1B4), U4.55 (IO2_55)
/BG: J2.11, U7.11 (1A5)
/BGACK: J2.12, U7.8 (1A4)
/BGACK_3: U4.70 (IO2_70), U7.9 (1B4)
/BG_3: U4.71 (IO2_71), U7.10 (1B5)
/BR: J2.13, U7.7 (1A3)
/BR_3: U4.69 (IO2_69), U7.6 (1B3)
/CLK: R3.2, U4.62 (IO2_62/GCLK2)
/CLK_STE: J2.15, R3.1
/D0: J2.5, U3.47 (1D1), U5.2 (1Q1)
/D1: J2.4, U3.46 (1D2), U5.3 (1Q2)
/D2: J2.3, U3.44 (1D3), U5.5 (1Q3)
/D3: J2.2, U3.43 (1D4), U5.6 (1Q4)
/D4: J2.1, U3.41 (1D5), U5.8 (1Q5)
/D5: J2.68, U3.40 (1D6), U5.9 (1Q6)
/D6: J2.67, U3.38 (1D7), U5.11 (1Q7)
/D7: J2.66, U3.37 (1D8), U5.12 (1Q8)
/D8: J2.65, U3.36 (2D1), U5.13 (2Q1)
/D9: J2.64, U3.35 (2D2), U5.14 (2Q2)
/D10: J2.63, U3.33 (2D3), U5.16 (2Q3)
/D11: J2.62, U3.32 (2D4), U5.17 (2Q4)
/D12: J2.61, U3.30 (2D5), U5.19 (2Q5)
/D13: J2.60, U3.29 (2D6), U5.20 (2Q6)
/D14: J2.59, U3.27 (2D7), U5.22 (2Q7)
/D15: J2.58, U3.26 (2D8), U5.23 (2Q8)
/DATA_RD_LTCH_HB: U3.25 (2LE), U4.50 (IO1_50)
/DATA_RD_LTCH_LB: U3.48 (1LE), U4.49 (IO1_49)
/DATA_RD_OE: U3.1 (1OE), U3.24 (2OE), U4.38 (IO1_38)
/DATA_WR_LTCH_HB: U4.36 (IO1_36), U5.25 (2LE)
/DATA_WR_LTCH_LB: U4.40 (IO1_40), U5.48 (1LE)
/DATA_WR_OE: U4.41 (IO1_41), U5.1 (1OE), U5.24 (2OE)
/DTACK: J2.10, U7.22 (2A5)
/DTACK_3: U4.76 (IO2_76), U7.23 (2B5)
/E: J2.22, U1.4 (1A2)
/E_3: U1.5 (1B2), U4.53 (IO2_53)
/FC0: J2.30, U1.22 (2A5)
/FC0_3: U1.23 (2B5), U4.66 (IO2_66)
/FC1: J2.29, U1.21 (2A4)
/FC1_3: U1.20 (2B4), U4.64 (IO2_64/GCLK3)
/FC2: J2.28, U1.14 (2A1)
/FC2_3: U1.15 (2B1), U4.57 (IO2_57)
/HALT: J2.19, U7.4 (1A2)
/HALT_3: U4.68 (IO2_68), U7.5 (1B2)
/IPL0: J2.27, U1.11 (1A5)
/IPL0_3: U1.10 (1B5), U4.56 (IO2_56)
/IPL1: J2.26, U1.17 (2A2)
/IPL1_3: U1.16 (2B2), U4.58 (IO2_58)
/IPL2: J2.25, U1.18 (2A3)
/IPL2_3: U1.19 (2B3), U4.61 (IO2_61)
/LDS: J2.8, U7.18 (2A3)
/LDS_3: U4.74 (IO2_74), U7.19 (2B3)
/PICLK: R4.2, U4.12 (IO1_12/GCLK0)
/PICLK_OUT: J1.7 (GCLK0/GPIO4), R4.1
/RESET: J2.20, U7.3 (1A1)
/RESET_3: U4.67 (IO2_67), U7.2 (1B1)
/RW: J2.9, U7.21 (2A4)
/RW_3: U4.75 (IO2_75), U7.20 (2B4)
/SA0: J1.29 (GCLK1/GPIO5), U4.34 (IO1_34)
/SA1: J1.5 (SCL/GPIO3), U4.28 (IO1_28)
/SA2: J1.3 (SDA/GPIO2), U4.27 (IO1_27)
/SD0: J1.24 (~CE0/GPIO8), U2.47 (1D1), U3.2 (1Q1), U4.2 (IO1_2), U5.47 (1D1), U6.47 (1D1)
/SD1: J1.21 (MISO0/GPIO9), U2.46 (1D2), U3.3 (1Q2), U4.3 (IO1_3), U5.46 (1D2), U6.46 (1D2)
/SD2: J1.19 (MOSI0/GPIO10), U2.44 (1D3), U3.5 (1Q3), U4.4 (IO1_4), U5.44 (1D3), U6.44 (1D3)
/SD3: J1.23 (SCLK0/GPIO11), U2.43 (1D4), U3.6 (1Q4), U4.5 (IO1_5), U5.43 (1D4), U6.43 (1D4)
/SD4: J1.32 (PWM0/GPIO12), U2.41 (1D5), U3.8 (1Q5), U4.6 (IO1_6), U5.41 (1D5), U6.41 (1D5)
/SD5: J1.33 (PWM1/GPIO13), U2.40 (1D6), U3.9 (1Q6), U4.7 (IO1_7), U5.40 (1D6), U6.40 (1D6)
/SD6: J1.8 (GPIO14/TXD), U2.38 (1D7), U3.11 (1Q7), U4.26 (IO1_26), U5.38 (1D7), U6.38 (1D7)
/SD7: J1.10 (GPIO15/RXD), U2.37 (1D8), U3.12 (1Q8), U4.21 (IO1_21), U5.37 (1D8), U6.37 (1D8)
/SD8: J1.36 (GPIO16), U2.36 (2D1), U3.13 (2Q1), U4.17 (IO1_17), U5.36 (2D1), U6.36 (2D1)
/SD9: J1.11 (GPIO17), U2.35 (2D2), U3.14 (2Q2), U4.16 (IO1_16), U5.35 (2D2), U6.35 (2D2)
/SD10: J1.12 (GPIO18/PWM0), U2.33 (2D3), U3.16 (2Q3), U4.20 (IO1_20), U5.33 (2D3), U6.33 (2D3)
/SD11: J1.35 (GPIO19/MISO1), U2.32 (2D4), U3.17 (2Q4), U4.8 (IO1_8), U5.32 (2D4), U6.32 (2D4)
/SD12: J1.38 (GPIO20/MOSI1), U2.30 (2D5), U3.19 (2Q5), U4.15 (IO1_15), U5.30 (2D5), U6.30 (2D5)
/SD13: J1.40 (GPIO21/SCLK1), U2.29 (2D6), U3.20 (2Q6), U4.14 (IO1_14/GCLK1), U5.29 (2D6), U6.29 (2D6)
/SD14: J1.15 (GPIO22), U2.27 (2D7), U3.22 (2Q7), U4.19 (IO1_19), U5.27 (2D7), U6.27 (2D7)
/SD15: J1.16 (GPIO23), U2.26 (2D8), U3.23 (2Q8), U4.18 (IO1_18), U5.26 (2D8), U6.26 (2D8)
/SOE: J1.31 (GCLK2/GPIO6), U4.35 (IO1_35)
/SWE: J1.26 (~CE1/GPIO7), U4.29 (IO1_29)
/TCK: J1.37 (GPIO26), U4.24 (TCK)
/TDI: J1.13 (GPIO27), R1.2, U4.23 (TDI)
/TDO: J1.22 (GPIO25), U4.25 (TDO)
/TMS: J1.18 (GPIO24), R2.2, U4.22 (TMS)
/UDS: J2.7, U7.17 (2A2)
/UDS_3: U4.73 (IO2_73), U7.16 (2B2)
/VMA: J2.21, U1.3 (1A1)
/VMA_3: U1.2 (1B1), U4.52 (IO2_52)
/VPA: J2.23, U1.7 (1A3)
/VPA_3: U1.6 (1B3), U4.54 (IO2_54)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.6 (GND), J1.9 (GND), J1.14 (GND), J1.20 (GND), J1.25 (GND), J1.30 (GND), J1.34 (GND), J1.39 (GND), J2.16, J2.17, J2.56, J2.57, J3.2, U1.1 (1OE), U1.12 (GND), U1.13 (2OE), U2.4 (GND), U2.10 (GND), U2.15 (GND), U2.21 (GND), U2.28 (GND), U2.34 (GND), U2.39 (GND), U2.45 (GND), U3.4 (GND), U3.10 (GND), U3.15 (GND), U3.21 (GND), U3.28 (GND), U3.34 (GND), U3.39 (GND), U3.45 (GND), U4.10 (GNDIO), U4.11 (GNDINT), U4.32 (GNDIO), U4.46 (GNDIO), U4.60 (GNDIO), U4.65 (GNDINT), U4.79 (GNDIO), U4.93 (GNDIO), U5.4 (GND), U5.10 (GND), U5.15 (GND), U5.21 (GND), U5.28 (GND), U5.34 (GND), U5.39 (GND), U5.45 (GND), U6.4 (GND), U6.10 (GND), U6.15 (GND), U6.21 (GND), U6.28 (GND), U6.34 (GND), U6.39 (GND), U6.45 (GND), U7.1 (1OE), U7.12 (GND), U7.13 (2OE), U8.1 (GND)

## Commit log

2022-07-12 First check in of WIP-PiStormST repo
2022-07-12 Adding something to boot!
2022-07-13 New function (that should end up in platforms) to allow 32 bit processors to work on the ST (0xFFnnnnnn should be translated to 0x00nnnnnn)
2022-07-14 Removing confusingly named out of date bistreams
2022-07-14 Adding a snapshot 570 bitstream
2022-07-20 Bus error almost working -- able to boot a stock ROM now.
2022-07-20 Bus error almost working: can boot a stock TOS
2022-07-20 Still not happy with the RTL: reset not working, bus arb should be better
2022-07-20 Unconvincing bus arb
2022-07-20 Recording the error address. Problems persist with the IACK cycle causing bus errors still
2022-07-25 First steps at building a debug version of emulator and restructuring the ST version
2022-07-26 Slow clock to improve stability -- mutexs not helping
2022-08-01 Speculative IPL tweak
2022-08-02 Using RESET line to optimise bus error check -- bus accesses still only at 50%, however.
2022-08-02 Using RESET to optimise bus error handling (no ST->PI reset ATM)
2022-08-02 Nasty hack to compare IPL just before invoking the interrupt handler
2022-08-04 standardising calls in emluator.c to go through the same function
2022-08-04 ekeing out perhaps 2% extra speed by bypassing check on write. Probably bad.
2022-08-04 Much hacking of the CPU cycle to optimise for STE
2022-08-04 Full speed write, but only half speed read. Nasty hack that ignores write bus errors -- needs a proper looking at
2022-08-04 Delete bitstream-570.svf
    Out of date
2022-08-26 Deliberately backtracking to a more 'by the book' 68k state machine. Slow, but a starting point.
2022-08-28 S0-7 by the book seems to be working. Slow as molasses. Work back from here
2022-10-08 Revert "S0-7 by the book seems to be working. Slow as molasses. Work back from here"
    This reverts commit 292b3f12ce58afd26f34c23d522de0aacc3afeb7.
2022-10-08 Revert "Deliberately backtracking to a more 'by the book' 68k state machine. Slow, but a starting point."
    This reverts commit cd1fd31838e045c6d0f76dc8ce47c3b3187d6504.
2022-10-08 Revert "Delete bitstream-570.svf"
    This reverts commit ba2ca788da8ea91008d444008d8e44d0b99af44f.
2022-10-12 Taking the verilog back to d941a6eee1872c2690b29894084a78d80015c0fa "Much hacking of the CPU cycle to optimise for STE"
2022-10-14 Optimising read and writes by removing check-before-access (for blind write support) and removing inline shifts
2022-10-15 Bus error properly handled for reads and writes plus optimisations
2022-10-21 Optimising write terminate and read latch, but cannot optimise read terminate any more -- irksome. Still stuck at 2.5MB/s on read.
2022-10-22 Realised I had a redundant op_rw termination check. Removed and seems stable at 2.5/3.7. Working next on a new bus error idea.
2022-10-22 Working towards doing away with the reset-on-buserr hack. Returning special code on read bus errors
2022-10-22 Only checking bus errors on read -- looking for special 0xBE12 code.
2022-10-22 Seems working with early latch except when in sync bus access
2022-10-23 Adding support for testing the ST's memory a la buptest
2022-10-29 Just aiming for stablity now
2022-10-29 Improving ataristest
2022-10-29 Just aiming for stablity now (emulator side commit)
2022-10-30 This appears to be the limit of shortening the read cycle on the ST, but it has no material effect to the read speed. The rest would have to come from a faster Pi, or software optimisation, I think.
2022-10-30 Tiding up read and write functions
2022-11-02 Hacking together a graphics card emulator
2022-11-02 Speed is up to scratch on the virtual graphics card now
2022-11-28 Adding the current firmware bitstream, to avoid confusion
2022-12-07 More basic ataritest & makefile
2022-12-08 Ataritest now actually writes >_>
2022-12-13 Updated ataritest to hopefully more useful ranges
2022-12-17 Fixed data latching issue -- no speed attempt, but correcting a flipflop/latch mix up
2022-12-28 Working in no-DMA mode with my flip-flop board and a pi 3A
2022-12-28 Working on my flipflop board with nodma.
2023-01-07 Going back to amiga state machine and modding again to try to harmonise latch/flipflop logic. No bus arb yet.
2023-01-07 Fixing up some ataritest issues
2023-01-07 Working with corrected autovectored IACK on the flipflop board
2023-01-07 Correcting typo in rom declaration
2023-01-07 Re-enabling old busarb logic.
2023-01-07 Adding a 570 build for this commit only
2023-01-11 Introducing support for reset on ST variant.
2023-01-11 Emulator-side support for reset on ST.
2023-08-09 Started work on an STE pistorm
2023-08-11 Schematic tentatively finished
2023-08-15 Started a layout
2023-08-18 Upgrade to Kicad6 happened. Need to test measurements before routing as don't know about layout yet.
2023-08-20 Trying a different layout
2023-08-24 Working on tightening the gap to the two level shifters and the CPU pins
2023-08-29 squishing up to avoid post
2023-08-29 Started routeing address lines
2023-09-01 Most major connections done. South-side CPLD to work on next
2023-09-01 Primary routeing completed. Many DRC errors.
2023-09-05 Routing complete and passing DRC. Query PLCC socket alignment. Will change to a single footprint.
2023-09-05 Changing separate pin headers for PLCC plug footprint. DRC not passing yet
2023-09-05 Passing DRC. Fixed 3d model issue with the plug footprint.
2023-09-06 Adding a support post hole.
2023-09-07 Squeezed down to 100mm width to fit in the PCBWay cheaper bracket
2023-09-07 Resized vias to hit another PCBWay price break
